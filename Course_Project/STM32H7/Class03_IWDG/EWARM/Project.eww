<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Class03_IWDG.ewp</path>
  </project>
  <batchBuild />
</workspace>
